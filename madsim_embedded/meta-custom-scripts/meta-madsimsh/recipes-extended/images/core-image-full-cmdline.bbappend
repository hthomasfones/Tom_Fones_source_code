IMAGE_INSTALL:append = " madsimsh"
IMAGE_INSTALL:append = " madsimui"
IMAGE_INSTALL:append = " madsimko"

