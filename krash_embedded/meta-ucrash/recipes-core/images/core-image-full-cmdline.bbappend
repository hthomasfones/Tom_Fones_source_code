IMAGE_INSTALL:append = " ucrash"
IMAGE_INSTALL:append = " gdb strace valgrind"
