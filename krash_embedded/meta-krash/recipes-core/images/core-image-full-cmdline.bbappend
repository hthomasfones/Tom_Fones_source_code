IMAGE_INSTALL:append = " kernel-module-krash"
