IMAGE_INSTALL:append = " krashsetup.sh"

